FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

COMPATIBLE_MACHINE = "(wandboard|wandboard-custom)"
